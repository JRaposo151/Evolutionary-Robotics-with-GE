Commit message: Update body_Link_CUBE.urdf

File: URDFs_set/body_Link_CUBE.urdf (robot description, URDF)
Before this commit: robot BODY_LINK, 1 links, 0 joints
Links:
- link body_link: geometry collision box size=0.046 0.046 0.046; visual box size=0.046 0.046 0.046
